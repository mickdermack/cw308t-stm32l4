# Repository mickdermack/cw308t-stm32l4

## KiCad design cw308t-stm32l4.kicad_pcb

Parts:
C1, C2, C4, C5, C6: 100n; C_0603_1608Metric
C3: 4.7u; C_0603_1608Metric
J1: CW308T_CONNBOARD
J2: Conn_02x03_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 100R; R_0603_1608Metric
R2: 10R; R_1206_3216Metric
R3, R5, R6, R7: 10k; R_0603_1608Metric
U1: STM32L432KCUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm

Connections:
/BOOT0: J1.A17 (PDIC), J1.B11 (HDR1), R6.1, U1.31 (PH3)
/CAN_RX: J2.2, R7.2, U1.21 (PA11)
/CAN_TX: J2.3, U1.22 (PA12)
/CLKI: R1.2, U1.2 (PC14), U1.6 (PA0)
/CLKO: J1.A5 (CLKIN), U1.18 (PA8)
/GPIO3: J1.A9 (GPIO3), U1.14 (PB0)
/GPIO4: J1.A10 (GPIO4), U1.3 (PC15)
/GPIO5: J1.B15 (HDR5), U1.28 (PB5)
/I2C_SCL: J1.B13 (HDR3), U1.29 (PB6)
/I2C_SDA: J1.B14 (HDR4), U1.30 (PB7)
/LED1: J1.C18 (LED1), U1.7 (PA1)
/LED2: J1.C19 (LED2), U1.8 (PA2)
/LED3: J1.C20 (LED3), U1.9 (PA3)
/NRST: J1.A11 (NRST), J1.B8 (JTAG_NRST), U1.4 (NRST)
/RX: J1.A8 (GPIO2), U1.20 (PA10)
/SPI_MISO: J1.A13 (MISO), U1.12 (PA6)
/SPI_MOSI: J1.A14 (MOSI), U1.13 (PA7)
/SPI_SCLK: J1.A12 (SCK), U1.11 (PA5)
/SPI_SS: J1.A18 (PDID), U1.10 (PA4)
/TCK: J1.B6 (JTAG_TCK), U1.24 (PA14)
/TDI: J1.B3 (JTAG_TDI), U1.25 (PA15)
/TDO: J1.B4 (JTAG_TDO), U1.26 (PB3)
/TMS: J1.B5 (JTAG_TMS), U1.23 (PA13)
/TRST: J1.B2 (JTAG_TRST), U1.27 (PB4)
/TX: J1.A7 (GPIO1), U1.19 (PA9)
/USB_VBUS: J2.5, R3.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.A2 (GND), J1.A4 (GND), J1.A6 (GND), J1.A15 (GND), J1.A16 (GND), J1.B1 (GND), J1.B9 (GND), J1.B10 (GND), J1.C1 (GND), J1.C4 (GND), J1.C7 (GND), J1.C9 (GND), J1.C10 (GND), J1.C16 (GND), J1.C17 (GND), J2.6, JP1.1 (A), R5.2, R6.2, U1.32 (VSS), U1.33 (VSS)
unnamed: C3.1, C4.1, C5.1, J1.C2 (SHUNTL), R2.2, U1.1 (VDD), U1.17 (VDD)
unnamed: J1.A3 (CLKOUT), R1.1
unnamed: J1.C3 (SHUNTH), J1.C5 (FILT_LP), J1.C6 (FILT_HP), R2.1
unnamed: JP1.2 (B), U1.16 (VSS)
unnamed: JP2.2 (B), R7.1
unnamed: R3.2, R5.1, U1.15 (PB1)
VCC: C1.1, C2.1, C6.1, J1.A20 (VREF), J1.B7 (JTAG_VREF), J1.B12 (HDR2), J1.C8 (FILTIN), J1.C14 (VCC3.3V), J2.4, JP2.1 (A), U1.5 (VDDA)

Notes on the sheet:
USB/CAN
Open for STM32F038
Close for CAN

Board: 2 copper layers, 53.0 x 65.0 mm, 17 parts (3 on the bottom side), 34 nets.

## Commit log

2019-08-05 Reworked with ic rotated by 90 degrees
2019-08-06 Somewhat better ground
2019-08-06 2x5 pin header, minor improvements
2019-08-06 Add license
2019-08-06 Add nicknames and rev to silkscreen
2019-08-06 Moved solder pad
2019-08-06 Minor beautifications
2019-08-06 Fix clearance of VCC vs. pad 2 of JP2
2019-08-06 Add license to silkscreen
2019-09-12 Larger silkscreen stuff, fixes #2
2019-09-12 Ignore *.sch-bak
2019-09-12 Swap UART, I2C (see #1); add more visible pin 1 marker for STM32
2019-09-12 Swap GPIO3 and SPI_SS (see #1)
2019-09-12 Bump schematic and board revision
2020-04-04 Remove -cache.lib file

Notices in the files:
cw308t-stm32l4.kicad_pcb:
Licensed under CERN OHL v.1.2 or later
© 2019 mickdermack, aveexy
